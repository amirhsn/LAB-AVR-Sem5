.INCLUDE "M8535DEF.INC"
.ORG 0
//AMIR HUSEIN
RJMP MAIN
MAIN:
LDI R16, LOW(RAMEND)
OUT SPL, R16
LDI R16, HIGH(RAMEND)
OUT SPH, R16

//INISIALISASI POINTER
LDI ZL, LOW($60)
LDI ZH, HIGH($60)
//INISIALISASI COUNTER
LDI R18,0
LD R19, Z+
LD R20, Z+
RCALL OPR

AKHIR: RJMP AKHIR

OPR:
CPI R18, $0A
BREQ AKHIR
INC R18
LD R21, Z+
LD R22, Z+
//CEK PULUHAN
CP R20, R22
BREQ CEKSAT
BRLO OPR
MOV R20, R22
MOV R19, R21
RJMP OPR

CEKSAT:
CP R19, R21
BRLO OPR
MOV R19, R21
RJMP OPR
