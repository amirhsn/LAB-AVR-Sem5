.INCLUDE "M8535DEF.INC"
.ORG 0

RJMP MAIN
MAIN:
LDI R16, LOW(RAMEND)
OUT SPL, R16
LDI R16, HIGH(RAMEND)
OUT SPH, R16

//INISIALISASI POINTER
LDI ZL, LOW(2*DAT)
LDI ZH, HIGH(2*DAT)
//INISIALISASI COUNTER
LDI R19,0
LPM R20, Z+
RCALL OPR

AKHIR: RJMP AKHIR

OPR:
LPM R21, Z+
CP R20, R21
BRSH SKIP
MOV R20, R21
SKIP:
INC R19
CPI R19, $0F
BREQ AKHIR
RJMP OPR

.ORG $80
DAT: .DB $43,$4A,$3A,$2A,$11,$4D,$8C,$9A,$9E,$77,$76,$75,$12,$13,$01
