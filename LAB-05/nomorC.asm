.INCLUDE "M8535DEF.INC"
.ORG 0

RJMP MAIN
MAIN:
LDI R16, LOW(RAMEND)
OUT SPL, R16
LDI R16, HIGH(RAMEND)
OUT SPL, R16

//B INPUT, A OUTPUT
LDI R16, 0
OUT DDRB, R16
LDI R16, 0X0FF
OUT DDRA, R16

//BACA INPUT
READ1:
LDI R23, 0
LDI R18, 8
IN R22, PINB

READ2:
LSL R22
ROR R23

DEC R18
BRNE READ2
OUT PORTA, R23

RJMP READ1

AKHIR: RJMP AKHIR

//SUBRUTIN UNTUK MEMBUANG WAKTU
DELAY:
LDI R23, 99
LUP:
DEC R23
BRNE LUP
RET
