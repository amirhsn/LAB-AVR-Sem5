.INCLUDE "M8535DEF.INC"
.ORG 0

RJMP MAIN

MAIN:
LDI R16, LOW(RAMEND)
OUT SPL, R16
LDI R16, HIGH(RAMEND)
OUT SPH, R16

LDI R23, 0X0FF
LDI R24, 0X0FF
LDI R22, 0X0CD
LDI R21, 0X0AB
RCALL OPP

LDI R22, 0X0AB
LDI R21, 0X90
RCALL OPP

LDI R22, 0X7D
LDI R21, 0X56
RCALL OPP

LDI R22, 0X0E2
LDI R21, 0X0C4
RCALL OPP

LDI R22, 0X0DA
LDI R21, 0X0BE
RCALL OPP

AKHIR: RJMP AKHIR


OPP:
ADD R23, R22
ADC R24, R21
ADC R25, R1
RET
