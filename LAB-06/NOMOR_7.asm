.INCLUDE "M8535DEF.INC"
.ORG 0

RJMP MAIN
MAIN:
LDI R16, LOW(RAMEND)
OUT SPL, R16
LDI R16, HIGH(RAMEND)
OUT SPH, R16

//PORT A SEBAGAI OUTPUT
LDI R20, $FF
OUT DDRA, R20

//INISIALISASI COUNTER
AWAL:
LDI R16,0

//INISIALIASI POINTER Z
LDI ZL, LOW(2*DAT)
LDI ZH, HIGH(2*DAT)

//MULAI
L1:
LPM R20, Z+
OUT PORTA, R20
RCALL DELAY
INC R16
CPI R16, $10
BRLO L1
RJMP AWAL

//SUBRUTIN DELAY 1 DETIK
DELAY:
LDI R21, 11
L21:
LDI R22, 0
L22:
LDI R23, 0
L23:
DEC R23
BRNE L23
DEC R22
BRNE L22
DEC R21
BRNE L21
RET

.ORG 80
DAT: 
.DB $3F, $06, $5B, $4F, $66, $6D, $7D, $07, $7F, $6F, $77, $7C, $39, $5E, $79, $71
